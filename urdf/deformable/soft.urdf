Commit message: Add files via upload

File: urdf/deformable/soft.urdf (robot description, URDF)
Before this commit: robot isosphere, 2 links, 1 joints
Links:
- removed link ball
Joints:
- removed joint attach
